# IAR project TermProject_04.ewp, settings and files
configuration Debug (CMake_ARM, debug)
  General.CoreVariant: 38
  General.FPU2: 0
configuration Release (CMake_ARM)
  as the first configuration, except:
